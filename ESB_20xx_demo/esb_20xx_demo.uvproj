# Keil uVision project esb_20xx_demo.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ING2000 INGCHIPS
  cpu: CLOCK(128000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x2000000-0x2200000) IRAM(0x20000000-0x20008000)
  output: ESB_920_ROM_with_source +hex
  AfterMake: fromelf.exe --bin -o ESB_920_ROM_with_source.bin ./output/ESB_920_ROM_with_source.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --gnu
  c include: sdk/bundles/rom/inc;sdk/bundles/rom/inc/os;sdk/src/BSP;sdk/src/FWlib;sdk/src/StartUP/ing20;sdk/src/Tools;sdk/src
  library: MicroLIB
  memory RVCT4: ROM 33574912 size 241664
  memory RVCT9: RAM 536889216 size 30848
  group APP
    ./src/: main.c profile.c
  group StartUP
    ./src/: startup_ing2000.s
    sdk/bundles/rom/ING20xx/: symdefs.m
  group BSP
    sdk/src/BSP/: eflash.c
  group FWlib
    sdk/src/FWlib/: peripheral_adc.c peripheral_gpio.c peripheral_i2c.c peripheral_pinctrl.c peripheral_pwm.c peripheral_rtc.c peripheral_ssp.c peripheral_sysctrl.c peripheral_timer.c peripheral_uart.c peripheral_asdm.c peripheral_dma.c peripheral_i2s.c peripheral_keyscan.c peripheral_pte.c peripheral_qdec.c peripheral_usb.c
  group Tools
    sdk/src/Tools/: trace.c
